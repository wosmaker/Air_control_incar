# Repository wosmaker/Air_control_incar

## KiCad design hardware/PCB air_controller/PCB air_controller 2.kicad_pcb

Parts:
C1, C2: C_Small; C_Disc_D3.0mm_W2.0mm_P2.50mm
C3, C4: CP1; CP_Radial_D10.0mm_P5.00mm
J1, J3: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J5: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical
Q1, Q2, Q3: MMBT2222L; SOT-23
Q4, Q5, Q6, Q7: s8550; SOT-23
R1, R2, R3, R4, R5, R6, R9, R12: R_Small; R_0603_1608Metric
R7, R8, R10, R11, R13: R_Small; R_0805_2012Metric
SW1, SW2: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm
U1: ATmega328-PU; DIP-28_W7.62mm
U2: mini_dc-dc; mini dc-dc
U3: st7735
Y1: Crystal; Crystal_SMD_HC49-SD

Connections:
+5V: C3.1, J1.1, J2.1, J3.1, J4.1, Q5.2 (E), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U1.7 (VCC), U1.20 (AVCC), U2.3, U3.8
+12V: C4.1, J5.1, Q4.2 (E), Q6.2 (E), Q7.2 (E), U2.1
GND: C1.1, C2.1, C3.2, C4.2, J4.2, J5.5, J5.6, Q1.2 (E), Q2.2 (E), Q3.2 (E), R7.1, R9.1, R12.1, SW1.C, SW1.S2, SW2.C, SW2.S2, U1.8 (GND), U1.22 (GND), U2.2, U2.4, U3.7
unnamed: C1.2, U1.9 (XTAL1/PB6), Y1.1
unnamed: C2.2, U1.10 (XTAL2/PB7), Y1.2
unnamed: Q1.1 (B), R8.1
unnamed: Q1.3 (C), R10.2
unnamed: Q2.3 (C), R11.2
unnamed: Q3.3 (C), R13.2
unnamed: Q4.1 (B), R10.1
unnamed: Q5.3 (C), U3.1
unnamed: Q6.1 (B), R11.1
unnamed: Q7.1 (B), R13.1
RX: J4.3, U1.3 (PD1)
TX: J4.4, U1.2 (PD0)
ao: U1.14 (PB0), U3.4
black_light: Q5.1 (B), U1.12 (PD6)
compressor: R8.2, U1.11 (PD5)
cs: U1.18 (PB4), U3.6
en1_a: R1.1, SW1.A, U1.26 (PC3)
en1_b: R3.1, SW1.B, U1.27 (PC4)
en1_btn: R6.1, SW1.S1, U1.28 (PC5)
en2_a: R2.1, SW2.A, U1.4 (PD2)
en2_b: R4.1, SW2.B, U1.5 (PD3)
en2_btn: R5.1, SW2.S1, U1.6 (PD4)
front_fan_pwm: Q2.1 (B), U1.16 (PB2)
front_fan_signal: J5.3, Q6.3 (C)
front_temp: J2.2, R9.2, U1.24 (PC1)
lcd_reset: U1.13 (PD7), U3.5
ldr: J1.2, R7.2, U1.23 (PC0)
rear_fan_pwm: Q3.1 (B), U1.15 (PB1)
rear_fan_signal: J5.4, Q7.3 (C)
rear_temp: J3.2, R12.2, U1.25 (PC2)
relay_compressor: J5.2, Q4.3 (C)
reset: J4.5, U1.1 (~RESET~/PC6)
sck: U1.19 (PB5), U3.2
sda: U1.17 (PB3), U3.3

Board: 2 copper layers, 35 parts (30 on the bottom side), 37 nets.

## Code that names these connections

File software/air_controller/pin.h:

 #pragma once

//  Arduino pin assignment
// 
//                   ATMega328p
//                    +-\/-+
//              PC6  1|    |28  PC5 (AI 5 / D19)
//        (D 0) PD0  2|    |27  PC4 (AI 4 / D18)
//        (D 1) PD1  3|    |26  PC3 (AI 3 / D17)
//        (D 2) PD2  4|    |25  PC2 (AI 2 / D16)
//   PWM+ (D 3) PD3  5|    |24  PC1 (AI 1 / D15)
//        (D 4) PD4  6|    |23  PC0 (AI 0 / D14)
//              VCC  7|    |22  GND
//              GND  8|    |21  AREF
//              PB6  9|    |20  AVCC
//              PB7 10|    |19  PB5 (D 13)
//   PWM+ (D 5) PD5 11|    |18  PB4 (D 12)
//   PWM+ (D 6) PD6 12|    |17  PB3 (D 11) PWM
//        (D 7) PD7 13|    |16  PB2 (D 10) PWM
//        (D 8) PB0 14|    |15  PB1 (D 9)  PWM
//                    +----+

// fan control **pwm with low frequency
#define _front_fan 				10	
#define _rear_fan					9

// left encoder **leften -> left encoder
#define _leften_outa			17
#define _leften_outb			18
#define _leften_btn				19

// right encoder **righten -> right encoder
#define _righten_outa			2
#define _righten_outb			3
#define _righten_btn			4	

// compressor control
#define _compressor				5

// lcd pin (spi)
#define tft_blacklight		6
#define tft_sck						13
#define tft_sda						11
#define tft_dc						8
#define tft_cs 						12
#define tft_reset					7

// sensor analog pin
#define _front_temp				A2
#define _rear_temp				A1

## Commit log

2019-06-23 initial software
2019-06-23 initail pin
2019-07-04 initial :: hardware
2019-07-07 inital software
2019-07-07 hardware :: fix brd
2019-07-17 software :: ver 1.0
2019-07-17 software :: fix bug display
2019-07-18 fix bug :: ver 1.01
